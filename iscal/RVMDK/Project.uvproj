# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USB_Device +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_LD,SYSTEM_SUPPORT_UCOS
  c include: ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\User;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\User\USB\inc;..\Libraries\UCOSII\CONFIG;..\Libraries\UCOSII\CORE;..\Libraries\UCOSII\PORT;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\ADC;..\SYSTEM\LCD;..\SYSTEM\LCD;..\SYSTEM\hz;..\SYSTEM\IIC;..\SYSTEM\24CXX;..\SYSTEM\FLASH;..\SYSTEM\SPI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_ld.s
  group CMSIS
    ../User/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USB-FS-Device_Driver
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB-User
    ../User/USB/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ../User/: usbio.c
  group User Source
    ../User/: main.c stm32f10x_it.c usart.c
  group Readme
    ../User/: Readme.txt
  group UCOSII
    ../Libraries/UCOSII/PORT/: os_cpu_c.c os_dbg.c os_cpu_a.asm
    ../Libraries/UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/ADC/: adc.c
    ../SYSTEM/LCD/: LCD.c
    ../SYSTEM/24CXX/: 24cxx.c
    ../SYSTEM/IIC/: myiic.c
    ../SYSTEM/FLASH/: flash.c
    ../SYSTEM/SPI/: spi.c
